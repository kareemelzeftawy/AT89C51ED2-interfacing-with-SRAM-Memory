# Keil uVision project ext_mem.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51ED2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x6FF) CLOCK(33000000) MODP2
  output: ext_mem +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: test_xram.c test_mem_asm.a51 test_all_mem.c
